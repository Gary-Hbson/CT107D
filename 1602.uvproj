# Keil uVision project 1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Dome +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Drive;.\User
  group Drive
    ./: STARTUP.A51
    ./User/: drive.c io.c onewire.c ds1302.c iic.c app.c time.c Ultrasonic.c it.c PWM.c 1602.c
  group App
    ./User/: main.c
